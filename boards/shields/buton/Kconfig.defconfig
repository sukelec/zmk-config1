## boards/shields/buton/Kconfig.defconfig
```kconfig
if SHIELD_BUTON

config ZMK_KEYBOARD_NAME
    default "buton"

endif # SHIELD_BUTON
```
